options:
  parameters:
    author: ar
    generate_options: qt_gui
    id: reading_MEP
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '20'
  states: {}
- name: drf_range
  id: variable_qtgui_range
  parameters:
    min_len: 7*60
    start: 7*60
    step: '30'
    stop: '10000'
    value: 7*60
    widget: slider
  states: {}
- name: mep8
  id: variable
  parameters:
    value: '"/media/research1/T9/vla data/mep08_b081_250710/sr10MHz"'
  states: {}
- name: new_samp_rate
  id: variable
  parameters:
    value: int(samp_rate/decimation)
  states: {}
- name: offset
  id: variable
  parameters:
    value: int(17521632530000000+60*7*samp_rate)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_message_debug_1
  id: blocks_message_debug
  parameters:
    log_level: debug
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.from_double(drf_range)
    period: '1000'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr, blocks, qtgui
      import pmt
      import numpy as np
      import digital_rf
      from PyQt5 import Qt
      import sys
      from datetime import datetime, timezone
      # -----------------------------
      # digital_rf_relseek_source block (unchanged except safer seconds_to_sample)
      # -----------------------------
      class digital_rf_relseek_source(gr.sync_block):
          def __init__(self, data_dir="", channel="", start_sec=0.0, subchannel=0):
              gr.sync_block.__init__(
                  self,
                  name="digital_rf_relseek_source",
                  in_sig=None,
                  out_sig=[np.complex64],
              )

              self.data_dir = data_dir
              self.channel = channel
              self.subchannel = subchannel

              self.reader = None
              self.fs = None
              self.start_sample = 0
              self.end_sample_excl = None   # IMPORTANT: end is exclusive
              self.cursor = 0

              self.message_port_register_in(pmt.intern("seek"))
              self.set_msg_handler(pmt.intern("seek"), self.handle_seek)

              if not self.data_dir or not self.channel:
                  print("[digital_rf_relseek_source] Set data_dir and channel in block properties")
                  return

              self._init_reader()
              self.seek_seconds(float(start_sec))

          def _init_reader(self):
              self.reader = digital_rf.DigitalRFReader(self.data_dir)
              chans = self.reader.get_channels()
              if self.channel not in chans:
                  raise ValueError(f"[digital_rf_relseek_source] Channel '{self.channel}' not found. Available: {chans}")

              b0, b1 = self.reader.get_bounds(self.channel)
              self.start_sample = int(b0)
              self.end_sample_excl = int(b1)

              props = self.reader.get_properties(self.channel)
              if "samples_per_second" not in props:
                  raise ValueError(f"[digital_rf_relseek_source] Missing 'samples_per_second'. Keys: {list(props.keys())}")
              self.fs = float(props["samples_per_second"])
              self.start_unix = self.start_sample / self.fs
              self.end_unix = (self.end_sample_excl - 1) / self.fs   # last valid sample time
              self.duration_s = (self.end_sample_excl - self.start_sample) / self.fs
              self.start_dt = datetime.fromtimestamp(self.start_unix, tz=timezone.utc)
              self.end_dt = datetime.fromtimestamp(self.end_unix,   tz=timezone.utc)
              print(
              f"[digital_rf_relseek_source] UTC start={self.start_dt.isoformat()} "
              f"end={self.end_dt.isoformat()} duration={self.duration_s:.3f}s")
              self.cursor = self.start_sample
              print(f"[digital_rf_relseek_source] Opened data_dir='{self.data_dir}', channel='{self.channel}', fs={self.fs} Hz, bounds=[{self.start_sample}, {self.end_sample_excl})")

          def seconds_to_sample(self, seconds_from_start: float) -> int:
              sample = int(self.start_sample + np.floor(seconds_from_start * self.fs))
              return self.clamp_sample(sample)

          def clamp_sample(self, sample_idx: int) -> int:
              if sample_idx < self.start_sample:
                  return self.start_sample
              last_valid = self.end_sample_excl - 1
              if sample_idx > last_valid:
                  return last_valid
              return sample_idx

          def seek_seconds(self, seconds_from_start: float):
              self.cursor = self.seconds_to_sample(seconds_from_start)
              print(f"[digital_rf_relseek_source] Seek to {seconds_from_start:.6f}s -> sample {self.cursor}")

          def seek_samples_relative(self, sample_offset: int):
              self.cursor = self.clamp_sample(self.start_sample + int(sample_offset))
              print(f"[digital_rf_relseek_source] Seek to sample_offset {sample_offset} -> sample {self.cursor}")

          def handle_seek(self, msg):
              try:
                  if self.reader is None:
                      print("[digital_rf_relseek_source] Ignoring seek: reader not initialized")
                      return

                  if pmt.is_real(msg):
                      self.seek_seconds(float(pmt.to_double(msg)))
                      return
                  if pmt.is_integer(msg):
                      self.seek_samples_relative(int(pmt.to_long(msg)))
                      return

                  py = pmt.to_python(msg)
                  if isinstance(py, float):
                      self.seek_seconds(py)
                  elif isinstance(py, int):
                      self.seek_samples_relative(py)
                  else:
                      raise ValueError(f"unsupported seek message type: {type(py)}")
              except Exception as e:
                  print("[digital_rf_relseek_source] Seek error:", e)

          def work(self, input_items, output_items):
              out = output_items[0]
              n = len(out)
              if self.reader is None:
                  out[:] = 0
                  return n
              if self.cursor >= self.end_sample_excl:
                  out[:] = 0
                  return n
              max_n = self.end_sample_excl - self.cursor
              nreq = min(n, max_n)
              try:
                  data = self.reader.read_vector(self.cursor, nreq, self.channel)
                  data = np.asarray(data, dtype=np.complex64)
                  got = len(data)
                  out[:got] = data
                  if got < n:
                      out[got:] = 0
                  self.cursor += got
              except Exception as e:
                  print("[digital_rf_relseek_source] Read error:", e)
                  out[:] = 0
                  self.cursor = min(self.cursor + 1, self.end_sample_excl)
              return n

      # -----------------------------
      # Top Block with automatic slider range
      # -----------------------------
      class top_block(gr.top_block):
          def __init__(self, data_dir, channel):
              gr.top_block.__init__(self, "DigitalRF Seek Example")

              # Instantiate digital_rf block
              self.drf_block = digital_rf_relseek_source(
                  data_dir=data_dir,
                  channel=channel,
                  start_sec=0.0
              )

              # Determine recording duration
              self.recording_duration = (self.drf_block.end_sample_excl - self.drf_block.start_sample) / self.drf_block.fs
              print(f"[top_block] Recording duration (s): {self.recording_duration:.6f}")

              # Slider variable
              self.seek_sec = 0.0

              # QT GUI Range (slider)
              self.qtgui_range = qtgui.RangeWidget(
                  float,
                  0.0,
                  self.recording_duration,
                  0.01,
                  self.seek_sec,
                  "Seek Seconds"
              )

              # Message Strobe to send slider value
              msg = pmt.from_double(self.seek_sec)
              self.strobe = blocks.message_strobe(msg, 50)  # 50 ms
              self.strobe.msg_connect(self.strobe, "strobe", self.drf_block, "seek")

              # Slider callback
              def slider_changed(value):
                  msg = pmt.from_double(value)
                  self.strobe.set_msg(msg)

              self.qtgui_range.connect(slider_changed)

              # Show slider in a window
              self.window = Qt.QWidget()
              self.layout = Qt.QVBoxLayout()
              self.window.setLayout(self.layout)
              self.layout.addWidget(self.qtgui_range)
              self.window.setWindowTitle("DigitalRF Seek Slider")
              self.window.show()

      # -----------------------------
      # Run the flowgraph
      # -----------------------------
      if __name__ == "__main__":
          data_dir = "path/to/data"  # set your DigitalRF folder
          channel = "chA"            # set your channel

          app = Qt.QApplication(sys.argv)
          tb = top_block(data_dir, channel)
          tb.start()
          tb.show()
          app.exec_()
    channel: '"chA"'
    data_dir: mep8
    start_sec: drf_range
    subchannel: '0'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-2.525e6 + 11e3 + 0.2e3 + 0.11e3 + 0.03e3'
    decim: decimation
    minoutbuf: '16392'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 150e3, 40e3, window.WIN_HAMMING)
    type: ccc
  states: {}
- name: gr_digital_rf_digital_rf_source_0
  id: gr_digital_rf_digital_rf_source
  parameters:
    channel0: chA
    end0: ''
    gapless: 'False'
    hide_msg_port: 'True'
    min_chunksize: '0'
    nchan: '1'
    repeat: 'False'
    start0: offset
    throttle: 'False'
    top_level_dir: mep8
  states: {state: disabled}
- name: lora_rx_1
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'False'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[False,True]'
    samp_rate: new_samp_rate
    sf: '12'
    soft_decoding: 'True'
    sync_word: '[0x12]'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: 500e3
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: 10e6
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [blocks_conjugate_cc_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_conjugate_cc_0, '0', qtgui_sink_x_0_0_0_0, '0']
- [blocks_message_strobe_0, strobe, epy_block_0, seek]
- [blocks_throttle2_0, '0', blocks_conjugate_cc_0, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', lora_rx_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_1, '0']
- [gr_digital_rf_digital_rf_source_0, '0', blocks_throttle2_0, '0']
- [lora_rx_1, out, blocks_message_debug_1, log]
- [lora_rx_1, out, blocks_message_debug_1, print]
- [lora_rx_1, out, blocks_message_debug_1, print_pdu]
- [lora_rx_1, out, blocks_message_debug_1, store]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
